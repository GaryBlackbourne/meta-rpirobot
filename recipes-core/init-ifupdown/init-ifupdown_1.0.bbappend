
FILESEXTRAPATHS:prepend := "${THISDIR}/patch:"
SRC_URI += " file://interfaces.patch"

