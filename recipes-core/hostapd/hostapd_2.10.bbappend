
FILESEXTRAPATHS:prepend := "${THISDIR}/patch:"
SRC_URI += " file://hostapd.conf.patch"

